options:
  parameters:
    author: flarroca
    generate_options: qt_gui
    id: obtaining_the_parameters
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    label: center frequency
    type: real
    value: '509142857'
  states: {}
- name: data_carriers
  id: variable
  parameters:
    value: 13*96*2**(mode-1)
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    label: Sampling Error
    start: 1-1e-4
    step: '1e-6'
    stop: 1+1e-4
    value: '1'
  states: {}
- name: freq_error
  id: variable_qtgui_range
  parameters:
    label: Frequency Error (Hz)
    start: '-samp_rate/200'
    step: '1'
    stop: samp_rate/200
    value: '0'
  states: {}
- name: guard
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,1
    label: Guard Interval
    label0: 1/4
    label1: 1/8
    label2: 1/16
    label3: 1/32
    num_opts: '4'
    option0: 1/4.0
    option1: 1/8.0
    option2: 1/16.0
    option3: 1/32.0
    orient: Qt.QHBoxLayout
    type: real
    value: 1/16
    widget: radio_buttons
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Mode
    label0: Mode 3 (8K)
    label1: Mode 2 (4K)
    label2: Mode 1 (2K)
    num_opts: '3'
    option0: '3'
    option1: '2'
    option2: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '3'
    widget: radio_buttons
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Channel noise
    start: '1e-9'
    step: '1e-6'
    stop: '10'
    value: '1e-9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6*(64/63)
  states: {}
- name: total_carriers
  id: variable
  parameters:
    value: 2**(mode+10)
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: total_carriers
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/iq_test
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(guard*total_carriers)
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: data_carriers
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: 13*108*2**(mode-1)+1
  states: {}
- name: isdbt_ofdm_synchronization_0
  id: isdbt_ofdm_synchronization
  parameters:
    cp_length: guard
    interpolate: 'True'
    mode: mode
  states: {}
- name: isdbt_tmcc_decoder_0
  id: isdbt_tmcc_decoder
  parameters:
    mode: mode
    print_params: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e6/2.0
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'FIRST: Try different values of mode and guard until you see a clear peak '
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 'SECOND: Configure the OFDM synchronization with the guard and mode you obtained before to get the rest of the parameters.'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,0,5,1
    name: '"Autocorrelation with a delay of total_carriers"'
    size: int(2*(1)*(total_carriers))
    srate: samp_rate
    type: float
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    antenna: Antenna B
    bandwidth: samp_rate
    bias: 'False'
    center_freq: center_freq
    gain: '0'
    lna_state: '11'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0, '0']
- [isdbt_ofdm_synchronization_0, '0', blocks_null_sink_0_0, '0']
- [isdbt_ofdm_synchronization_0, '0', isdbt_tmcc_decoder_0, '0']
- [isdbt_tmcc_decoder_0, '0', blocks_null_sink_0, '0']
- [low_pass_filter_0, '0', blocks_delay_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [low_pass_filter_0, '0', isdbt_ofdm_synchronization_0, '0']
- [soapy_sdrplay_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
